# Keil uVision project lessonx.uvprojx, settings and files
target dbg (6220000::V6.22::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lessonx.out
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\lesson27;..\qpc\include;..\qpc\ports\arm-cm\qxk\armclang;..\qpc\src\qf;..\qpc\src\qxk
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ./: main.c bsp.c bsp.h shape.c shape.h rectangle.c rectangle.h
  group QPC
    ../qpc/include/: qequeue.h qk.h qmpool.h qp.h qp_pkg.h qpc.h qs.h qs_dummy.h qs_pkg.h qsafe.h qstamp.h qv.h qxk.h
    ../qpc/ports/arm-cm/qxk/armclang/: qxk_port.c qs_port.h qp_port.h
    ../qpc/src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../qpc/src/qxk/: qxk_xthr.c qxk_sema.c qxk_mutex.c qxk.c
software components: CMSIS:CORE 6.1.0, Device:STM32Cube Framework:Classic 1.8.1, Device:STM32Cube HAL:Common 1.8.1, Device:STM32Cube HAL:Cortex 1.8.1, Device:STM32Cube HAL:GPIO 1.8.1, Device:STM32Cube HAL:PWR 1.8.1, Device:STM32Cube HAL:RCC 1.8.1, Device:Startup 2.6.3
